# Keil uVision project LEDFlash.uvprojx, settings and files
target LEDFlash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LEDFlash +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\SHT20;..\HARDWARE\OLED;..\HARDWARE\RTC;..\HARDWARE\MYTIME;..\HARDWARE\BMP;..\HARDWARE\MPU6050;..\HARDWARE\TIMER;..\HARDWARE\KALMAN;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MAX30102;..\HARDWARE\HC05;..\HARDWARE\BEEP;..\SYSTEM\usart2;..\HARDWARE\KEY;..\HARDWARE\GUI;..\HARDWARE\DinoGame;..\HARDWARE\CONTROL;..\HARDWARE\ADC;..\HARDWARE\IWDG;..\HARDWARE\FLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart2/: usart2.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: RTC.c
    ../HARDWARE/MYTIME/: mytime.c
    ../HARDWARE/BMP/: bmp.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KALMAN/: kalman.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MAX30102/: algorithm.c max30102.c myiic.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/GUI/: gui.c
    ../HARDWARE/DinoGame/: dinogame.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/SHT20/: sht20.c shtIIC.c
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/FLASH/: flash.c
  group README
    ../: readme.txt
